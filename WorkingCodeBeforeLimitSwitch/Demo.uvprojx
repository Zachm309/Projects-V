# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c RCServoSkeleton.c startup_stm32f303xe.s system_stm32f3xx.c LED.c LED.h UART.c UART.h SysClock.c SysClock.h stm32f303xe.h stepper.c Stepper.h utility.c utility.h MainAlt.c RCServo.h Macros.h ultraSonicInit.c ultraSonicInit.h LCD.h LCD.c scottMacro.c scottMacro.h DriveMotor.c DriveMotor.h keypad.c keypad.h Encoder.c Encoder.h Uart3.c limitSwitch.c
software components: CMSIS:CORE 5.6.0
